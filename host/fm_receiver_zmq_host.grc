options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: e310_fm_receiver_zmq_host
    output_language: python
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Audio Gain
    min_len: '100'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency (Hz)
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 98.5e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: RF Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: 1e6
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: xmlrpc_client
  id: xmlrpc_client
  parameters:
    addr: '"172.16.1.202"'
    callback: set_freq
    port: '30000'
    variable: freq
  states: {}
- name: xmlrpc_client0
  id: xmlrpc_client
  parameters:
    addr: '"172.16.1.202"'
    callback: set_rx_gain
    port: '30000'
    variable: rx_gain
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://172.16.1.202:9997
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pull_source_0_0_0
  id: zeromq_pull_source
  parameters:
    address: tcp://172.16.1.202:9999
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [zeromq_pull_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [zeromq_pull_source_0_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
