options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: e310_fm_receiver_zmq
    output_language: python
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: lpf_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: server_address
  id: variable
  parameters:
    value: '"172.16.1.202"'
  states: {}
- name: server_port
  id: variable
  parameters:
    value: '30000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_samp_rate)
  states: {state: disabled}
- name: blks2_rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/lpf_decim/1000)
    interp: '48'
    type: fff
  states: {}
- name: blks2_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/lpf_decim
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 98.5e6
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: lpf_decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '50'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: str(server_address)
    port: int(server_port)
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:9997
    timeout: '100'
    type: float
  states: {}
- name: zeromq_push_sink_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:9999
    timeout: '100'
    type: complex
  states: {}

connections:
- [blks2_rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [blks2_rational_resampler_xxx_0, '0', zeromq_push_sink_0, '0']
- [blks2_wfm_rcv_0, '0', blks2_rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', blks2_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', zeromq_push_sink_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
