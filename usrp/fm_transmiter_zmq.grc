options:
  parameters:
    author: julianajaime
    generate_options: no_gui
    id: fm_transmiter_zmq
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: lpf_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: server_address
  id: variable
  parameters:
    value: '"172.16.1.202"'
  states: {}
- name: server_port
  id: variable
  parameters:
    value: '30000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 426.5625e6
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: tx_gain
    samp_rate: samp_rate
    stream_args: fc32
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0_0
  id: xmlrpc_server
  parameters:
    addr: str(server_address)
    port: int(server_port)
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://*:9998
    bind: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_pull_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
